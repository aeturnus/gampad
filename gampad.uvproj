# Keil uVision project gampad.uvproj, settings and files
target Gampad (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Gampad
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: startup.s main.c
  group Drivers
    ./src/drivers/tm4c/: UART.c PLL.c SysTick.c ADC.c Timer0.c
  group Devices
    ./src/drivers/devices/: ST7735.c Input.c
  group System
    ./src/drivers/system/: time.c io.c switch.c hw.c display.c
  group Libs
    ./src/sws/: sws.c
